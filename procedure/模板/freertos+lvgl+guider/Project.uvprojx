# Keil uVision project Project.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32H753IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -Wno-invalid-source-encoding
  c include: .\gui_test\test\custom;.\gui_test\test\generated;.\gui_test\test\generated\events;.\USER
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\Project.sct
  group User
    ./USER/RTOS/: freertos.c
    ./USER/DWT/: dwt.c
    ./USER/GT911/: GT911.c
    ./USER/Touch/: Touch.c
    ./USER/IIC/: Touch_IIC.c PCF8574T_IIC.c
    ./USER/PCF8574/: pcf8574.c
  group LVGL/ui
    ./USER/GUI/: GUI_main.c
    ./gui_test/test/generated/: gg_utils.c
    ./gui_test/test/generated/screens/: gg_layer_bottom.c gg_layer_sys.c gg_layer_top.c gg_screen.c gg_screen_1.c
    ./gui_test/test/generated/events/: gg_event_layer_bottom.c gg_event_layer_sys.c gg_event_layer_top.c gg_event_screen.c gg_event_screen_1.c
    ./gui_test/test/generated/assets/images/: computer_72x72_RGB565_RLE.c bk1_1024x600_RGB565_RLE.c bk_1024x600_RGB565_RLE.c network_idle_32px_542853_easyicon_32x32_RGB565_RLE.c
    ./gui_test/test/generated/assets/fonts/: lv_font_NotoSerifSC_Medium_20.c
  group :CubeMX:CubeMX
    ./STM32CubeMX/Target_1/STM32CubeMX/Src/: main.c gpio.c stm32h7xx_it.c stm32h7xx_hal_msp.c system_stm32h7xx.c stm32h7xx_hal_timebase_tim.c dma2d.c fmc.c ltdc.c tim.c eth.c
    ./STM32CubeMX/Target_1/STM32CubeMX/MDK-ARM/: startup_stm32h753xx.s
  group :CubeMX:STM32 HAL Driver
    ./STM32CubeMX/Target_1/STM32CubeMX/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_ll_fmc.c stm32h7xx_hal_nor.c stm32h7xx_hal_sram.c stm32h7xx_hal_nand.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c
software components: CMSIS:CORE 6.4.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:FreeRTOS 11.3.0, RTOS:Config 11.3.0, RTOS:Core 11.3.0, RTOS:Event Groups 11.3.0, RTOS:Heap 11.3.0, RTOS:Timers 11.3.0, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0, Device:CubeMX 1.0.0, LVGL:Acceleration:GPU STM32-DMA2D 9.4.0, LVGL:Display 9.4.0, LVGL:Essential 9.4.0, LVGL:Libraries and Others:Libs RLE 9.4.0, LVGL:OS Abstraction Layer 9.4.0, LVGL:Porting:Display 9.4.0, LVGL:Porting:Input 9.4.0
