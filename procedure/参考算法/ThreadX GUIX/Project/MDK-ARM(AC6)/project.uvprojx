# Keil uVision project project.uvprojx, settings and files
target Flash (6240000::V6.24::ARMCLANG)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER, STM32H743xx, TX_ENABLE_STACK_CHECKING, TX_INCLUDE_USER_DEFINE_FILE,TX_EXECUTION_PROFILE_ENABLE,TX_CORTEX_M_EPK
  c misc: -Wno-invalid-source-encoding
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32H7xx\Include;..\..\Libraries\STM32H7xx_HAL_Driver\Inc;..\..\User\bsp\inc;..\..\User;..\..\User\bsp;..\..\User\fonts;..\..\User\usbx;..\..\User\guix;..\..\User\app;..\..\User\netx;..\..\User\filex;..\..\User\threadx;..\..\ThreadX\ports\cortex_m7\ac6\inc;..\..\ThreadX\common\inc;..\..\GUIX\common\inc;..\..\GUIX\ports\cortex_m7\ac6\inc;..\..\FileX\common\inc;..\..\FileX\ports\cortex_m7\gnu\inc;..\..\USBX\common\core\inc;..\..\USBX\common\usbx_device_classes\inc;..\..\USBX\common\usbx_stm32_device_controllers;..\..\USBX\ports\cortex_m7\gnu\inc;..\..\USBX\common\usbx_network\inc;..\..\USBX\common\usbx_host_classes\inc;..\..\USBX\common\usbx_host_controllers\inc;..\..\USBX\common\usbx_pictbridge\inc;..\..\USBX\common\usbx_stm32_host_controllers;..\..\USBX\common\usbx_host_classes\inc;..\..\USBX\common\usbx_host_controllers\inc;..\..\USBX\common\usbx_network\inc;..\..\USBX\common\usbx_pictbridge\inc;..\..\USBX\common\usbx_stm32_host_controllers;..\..\NetXDUO\ports\cortex_m7;..\..\NetXDUO\ports\cortex_m7\ac5\inc;..\..\NetXDUO\common\inc;..\..\NetXDUO\addons\BSD;..\..\NetXDUO\addons\auto_ip;..\..\NetXDUO\addons\cloud;..\..\NetXDUO\addons\dhcp;..\..\NetXDUO\addons\dns;..\..\NetXDUO\addons\ftp;..\..\NetXDUO\addons\http;..\..\NetXDUO\addons\lwm2m;..\..\NetXDUO\addons\mdns;..\..\NetXDUO\addons\mqtt;..\..\NetXDUO\addons\nat;..\..\NetXDUO\addons\pop3;..\..\NetXDUO\addons\ppp;..\..\NetXDUO\addons\pppoe;..\..\NetXDUO\addons\ptp;..\..\NetXDUO\addons\smtp;..\..\NetXDUO\addons\snmp;..\..\NetXDUO\addons\sntp;..\..\NetXDUO\addons\telnet;..\..\NetXDUO\addons\tftp;..\..\NetXDUO\addons\web;..\..\NetXDUO\addons\azure_iot;..\..\NetXDUO\crypto_libraries\inc;..\..\NetXDUO\crypto_libraries\ports\cortex-m7\ac5\inc;..\..\NetXDUO\nx_secure\inc;..\..\NetXDUO\nx_secure\ports;..\..\ThreadX\utility\execution_profile_kit
  asm define: TX_EXECUTION_PROFILE_ENABLE,TX_ENABLE_EXECUTION_CHANGE_NOTIFY
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group User
    ../../User/app/: main.c includes.h
    ../../User/threadx/: tx_user.h
    ../../User/guix/: gx_user.h
    ../../GUIX/ports/cortex_m7/ac6/inc/: gx_port.h
    ../../ThreadX/ports/cortex_m7/ac6/inc/: tx_port.h
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32h7xx_it.c stm32h7xx_hal_timebase_tim.c
    ../../User/bsp/src/: bsp_led.c bsp_dwt.c bsp_key.c bsp_timer.c bsp_beep.c bsp_tft_h7.c bsp_tft_lcd.c bsp_fmc_io.c bsp_cpu_rtc.c bsp_uart_fifo.c bsp_sdio_sd.c bsp_tim_pwm.c bsp_fmc_sdram.c bsp_ts_ft5x06.c bsp_ts_gt811.c bsp_ts_gt911.c bsp_ts_touch.c bsp_ts_stmpe811.c bsp_i2c_gpio.c bsp_i2c_eeprom_24xx.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group HAL_Driver
    ../../User/bsp/: stm32h7xx_hal_conf.h
    ../../Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_gpio.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_mdma.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_hcd.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_usb.c stm32h7xx_hal_eth.c stm32h7xx_hal_pcd.c stm32h7xx_hal_cec.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group SEGGER/HardFault
    ../../User/segger/HardFaultHandlerMDK/: HardFaultHandler.S SEGGER_HardFaultHandler.c
  group ThreadX/Ports
    ../../ThreadX/ports/cortex_m7/ac6/src/: tx_thread_context_restore.S tx_thread_context_save.S tx_thread_interrupt_control.S tx_thread_schedule.S tx_thread_stack_build.S tx_thread_system_return.S tx_timer_interrupt.S
    ../../ThreadX/ports/cortex_m7/ac6/example_build/sample_threadx/: tx_initialize_low_level.S
  group ThreadX/Source
    ../../ThreadX/common/src/: tx_block_allocate.c tx_block_pool_cleanup.c tx_block_pool_create.c tx_block_pool_delete.c tx_block_pool_info_get.c tx_block_pool_initialize.c tx_block_pool_performance_info_get.c tx_block_pool_performance_system_info_get.c tx_block_pool_prioritize.c tx_block_release.c tx_byte_allocate.c tx_byte_pool_cleanup.c tx_byte_pool_create.c tx_byte_pool_delete.c tx_byte_pool_info_get.c tx_byte_pool_initialize.c tx_byte_pool_performance_info_get.c tx_byte_pool_performance_system_info_get.c tx_byte_pool_prioritize.c tx_byte_pool_search.c tx_byte_release.c tx_event_flags_cleanup.c tx_event_flags_create.c tx_event_flags_delete.c tx_event_flags_get.c tx_event_flags_info_get.c tx_event_flags_initialize.c tx_event_flags_performance_info_get.c tx_event_flags_performance_system_info_get.c tx_event_flags_set.c tx_event_flags_set_notify.c tx_initialize_high_level.c tx_initialize_kernel_enter.c tx_initialize_kernel_setup.c tx_misra.c tx_mutex_cleanup.c tx_mutex_create.c tx_mutex_delete.c tx_mutex_get.c tx_mutex_info_get.c tx_mutex_initialize.c tx_mutex_performance_info_get.c tx_mutex_performance_system_info_get.c tx_mutex_prioritize.c tx_mutex_priority_change.c tx_mutex_put.c tx_queue_cleanup.c tx_queue_create.c tx_queue_delete.c tx_queue_flush.c tx_queue_front_send.c tx_queue_info_get.c tx_queue_initialize.c tx_queue_performance_info_get.c tx_queue_performance_system_info_get.c tx_queue_prioritize.c tx_queue_receive.c tx_queue_send.c tx_queue_send_notify.c tx_semaphore_ceiling_put.c tx_semaphore_cleanup.c tx_semaphore_create.c tx_semaphore_delete.c tx_semaphore_get.c tx_semaphore_info_get.c tx_semaphore_initialize.c tx_semaphore_performance_info_get.c tx_semaphore_performance_system_info_get.c tx_semaphore_prioritize.c tx_semaphore_put.c tx_semaphore_put_notify.c tx_thread_create.c tx_thread_delete.c tx_thread_entry_exit_notify.c tx_thread_identify.c tx_thread_info_get.c tx_thread_initialize.c tx_thread_performance_info_get.c tx_thread_performance_system_info_get.c tx_thread_preemption_change.c tx_thread_priority_change.c tx_thread_relinquish.c tx_thread_reset.c tx_thread_resume.c tx_thread_shell_entry.c tx_thread_sleep.c tx_thread_stack_analyze.c tx_thread_stack_error_handler.c tx_thread_stack_error_notify.c tx_thread_suspend.c tx_thread_system_preempt_check.c tx_thread_system_resume.c tx_thread_system_suspend.c tx_thread_terminate.c tx_thread_time_slice.c tx_thread_time_slice_change.c tx_thread_timeout.c tx_thread_wait_abort.c tx_time_get.c tx_time_set.c tx_timer_activate.c tx_timer_change.c tx_timer_create.c tx_timer_deactivate.c tx_timer_delete.c tx_timer_expiration_process.c tx_timer_info_get.c tx_timer_initialize.c tx_timer_performance_info_get.c tx_timer_performance_system_info_get.c tx_timer_system_activate.c tx_timer_system_deactivate.c tx_timer_thread_entry.c tx_trace_buffer_full_notify.c tx_trace_disable.c tx_trace_enable.c tx_trace_event_filter.c tx_trace_event_unfilter.c tx_trace_initialize.c tx_trace_interrupt_control.c tx_trace_isr_enter_insert.c tx_trace_isr_exit_insert.c tx_trace_object_register.c tx_trace_object_unregister.c tx_trace_user_event_insert.c txe_block_allocate.c txe_block_pool_create.c txe_block_pool_delete.c txe_block_pool_info_get.c txe_block_pool_prioritize.c txe_block_release.c txe_byte_allocate.c txe_byte_pool_create.c txe_byte_pool_delete.c txe_byte_pool_info_get.c txe_byte_pool_prioritize.c txe_byte_release.c txe_event_flags_create.c txe_event_flags_delete.c txe_event_flags_get.c txe_event_flags_info_get.c txe_event_flags_set.c txe_event_flags_set_notify.c txe_mutex_create.c txe_mutex_delete.c txe_mutex_get.c txe_mutex_info_get.c txe_mutex_prioritize.c txe_mutex_put.c txe_queue_create.c txe_queue_delete.c txe_queue_flush.c txe_queue_front_send.c txe_queue_info_get.c txe_queue_prioritize.c txe_queue_receive.c txe_queue_send.c txe_queue_send_notify.c txe_semaphore_ceiling_put.c txe_semaphore_create.c txe_semaphore_delete.c txe_semaphore_get.c txe_semaphore_info_get.c txe_semaphore_prioritize.c txe_semaphore_put.c txe_semaphore_put_notify.c txe_thread_create.c txe_thread_delete.c txe_thread_entry_exit_notify.c txe_thread_info_get.c txe_thread_preemption_change.c txe_thread_priority_change.c txe_thread_relinquish.c txe_thread_reset.c txe_thread_resume.c txe_thread_suspend.c txe_thread_terminate.c txe_thread_time_slice_change.c txe_thread_wait_abort.c txe_timer_activate.c txe_timer_change.c txe_timer_create.c txe_timer_deactivate.c txe_timer_delete.c txe_timer_info_get.c
  group ThreadX/Profile
    ../../ThreadX/utility/execution_profile_kit/: tx_execution_profile.c tx_execution_profile.h
  group GUIX/Source
    ../../GUIX/common/src/: gx_accordion_menu_create.c gx_accordion_menu_draw.c gx_accordion_menu_event_process.c gx_accordion_menu_position.c gx_animation_canvas_define.c gx_animation_complete.c gx_animation_create.c gx_animation_delete.c gx_animation_drag_disable.c gx_animation_drag_enable.c gx_animation_drag_event_process.c gx_animation_drag_tracking.c gx_animation_drag_tracking_start.c gx_animation_landing_speed_set.c gx_animation_slide_landing.c gx_animation_slide_landing_start.c gx_animation_start.c gx_animation_stop.c gx_animation_update.c gx_binres_language_count_get.c gx_binres_language_info_load.c gx_binres_language_table_load.c gx_binres_theme_load.c gx_brush_default.c gx_brush_define.c gx_button_background_draw.c gx_button_create.c gx_button_deselect.c gx_button_draw.c gx_button_event_process.c gx_button_select.c gx_button_siblings_deselect.c gx_canvas_alpha_set.c gx_canvas_arc_draw.c gx_canvas_block_move.c gx_canvas_circle_draw.c gx_canvas_composite_create.c gx_canvas_create.c gx_canvas_delete.c gx_canvas_dirty_mark.c gx_canvas_drawing_complete.c gx_canvas_drawing_initiate.c gx_canvas_ellipse_draw.c gx_canvas_glyphs_draw.c gx_canvas_hardware_layer_bind.c gx_canvas_hide.c gx_canvas_line_draw.c gx_canvas_memory_define.c gx_canvas_mouse_define.c gx_canvas_mouse_hide.c gx_canvas_mouse_show.c gx_canvas_offset_set.c gx_canvas_pie_draw.c gx_canvas_pixel_draw.c gx_canvas_pixelmap_blend.c gx_canvas_pixelmap_draw.c gx_canvas_pixelmap_get.c gx_canvas_pixelmap_rotate.c gx_canvas_pixelmap_tile.c gx_canvas_polygon_draw.c gx_canvas_rectangle_draw.c gx_canvas_rotated_text_draw.c gx_canvas_shift.c gx_canvas_show.c gx_canvas_text_draw.c gx_checkbox_create.c gx_checkbox_draw.c gx_checkbox_event_process.c gx_checkbox_pixelmap_set.c gx_checkbox_select.c gx_circular_gauge_angle_get.c gx_circular_gauge_angle_increment_calculate.c gx_circular_gauge_angle_set.c gx_circular_gauge_animation_set.c gx_circular_gauge_background_draw.c gx_circular_gauge_create.c gx_circular_gauge_draw.c gx_circular_gauge_event_process.c gx_circular_gauge_needle_dirty_mark.c gx_circular_gauge_needle_rectangle_calculate.c gx_circular_gauge_needle_rotate.c gx_context_brush_default.c gx_context_brush_define.c gx_context_brush_get.c gx_context_brush_pattern_set.c gx_context_brush_set.c gx_context_brush_style_set.c gx_context_brush_width_set.c gx_context_color_get.c gx_context_fill_color_set.c gx_context_font_get.c gx_context_font_set.c gx_context_line_color_set.c gx_context_pixelmap_get.c gx_context_pixelmap_set.c gx_context_raw_brush_define.c gx_context_raw_fill_color_set.c gx_context_raw_line_color_set.c gx_context_string_get.c gx_display_active_language_set.c gx_display_canvas_dirty.c gx_display_color_set.c gx_display_color_table_set.c gx_display_create.c gx_display_delete.c gx_display_driver_1bpp_block_move.c gx_display_driver_1bpp_canvas_copy.c gx_display_driver_1bpp_glyph_1bpp_draw.c gx_display_driver_1bpp_horizontal_line_draw.c gx_display_driver_1bpp_horizontal_pattern_line_draw.c gx_display_driver_1bpp_horizontal_pixelmap_line_draw.c gx_display_driver_1bpp_mouse_capture.c gx_display_driver_1bpp_mouse_restore.c gx_display_driver_1bpp_native_color_get.c gx_display_driver_1bpp_pixel_write.c gx_display_driver_1bpp_pixelmap_draw.c gx_display_driver_1bpp_pixelmap_rotate.c gx_display_driver_1bpp_row_pitch_get.c gx_display_driver_1bpp_simple_line_draw.c gx_display_driver_1bpp_vertical_line_draw.c gx_display_driver_1bpp_vertical_pattern_line_draw.c gx_display_driver_4bpp_block_move.c gx_display_driver_4bpp_canvas_copy.c gx_display_driver_4bpp_glyph_1bit_draw.c gx_display_driver_4bpp_glyph_4bit_draw.c gx_display_driver_4bpp_grayscale_setup.c gx_display_driver_4bpp_horizontal_line_draw.c gx_display_driver_4bpp_horizontal_pattern_line_draw.c gx_display_driver_4bpp_horizontal_pixelmap_line_draw.c gx_display_driver_4bpp_mouse_capture.c gx_display_driver_4bpp_mouse_restore.c gx_display_driver_4bpp_native_color_get.c gx_display_driver_4bpp_pixel_write.c gx_display_driver_4bpp_pixelmap_draw.c gx_display_driver_4bpp_pixelmap_rotate.c gx_display_driver_4bpp_row_pitch_get.c gx_display_driver_4bpp_simple_line_draw.c gx_display_driver_4bpp_vertical_line_draw.c gx_display_driver_4bpp_vertical_pattern_line_draw.c gx_display_driver_8bit_palette_native_color_get.c gx_display_driver_8bit_palette_rotated_setup.c gx_display_driver_8bit_palette_setup.c gx_display_driver_8bpp_block_move.c gx_display_driver_8bpp_canvas_copy.c gx_display_driver_8bpp_glyph_1bit_draw.c gx_display_driver_8bpp_glyph_3bit_draw.c gx_display_driver_8bpp_glyph_4bit_draw.c gx_display_driver_8bpp_horizontal_line_draw.c gx_display_driver_8bpp_horizontal_pattern_line_draw.c gx_display_driver_8bpp_horizontal_pixelmap_line_draw.c gx_display_driver_8bpp_mouse_capture.c gx_display_driver_8bpp_mouse_restore.c gx_display_driver_8bpp_pixel_write.c gx_display_driver_8bpp_pixelmap_blend.c gx_display_driver_8bpp_pixelmap_draw.c gx_display_driver_8bpp_pixelmap_rotate.c gx_display_driver_8bpp_rotated_block_move.c gx_display_driver_8bpp_rotated_canvas_copy.c gx_display_driver_8bpp_rotated_glyph_1bit_draw.c gx_display_driver_8bpp_rotated_glyph_3bit_draw.c gx_display_driver_8bpp_rotated_glyph_4bit_draw.c gx_display_driver_8bpp_rotated_horizontal_line_draw.c gx_display_driver_8bpp_rotated_horizontal_pattern_line_draw.c gx_display_driver_8bpp_rotated_horizontal_pixelmap_line_draw.c gx_display_driver_8bpp_rotated_pixel_write.c gx_display_driver_8bpp_rotated_pixelmap_draw.c gx_display_driver_8bpp_rotated_pixelmap_rotate.c gx_display_driver_8bpp_rotated_simple_line_draw.c gx_display_driver_8bpp_rotated_vertical_line_draw.c gx_display_driver_8bpp_rotated_vertical_pattern_line_draw.c gx_display_driver_8bpp_row_pitch_get.c gx_display_driver_8bpp_simple_line_draw.c gx_display_driver_8bpp_vertical_line_draw.c gx_display_driver_8bpp_vertical_pattern_line_draw.c gx_display_driver_16bpp_block_move.c gx_display_driver_16bpp_canvas_copy.c gx_display_driver_16bpp_horizontal_line_draw.c gx_display_driver_16bpp_horizontal_pattern_line_draw.c gx_display_driver_16bpp_mouse_capture.c gx_display_driver_16bpp_mouse_restore.c gx_display_driver_16bpp_pixel_write.c gx_display_driver_16bpp_pixelmap_blend.c gx_display_driver_16bpp_pixelmap_draw.c gx_display_driver_16bpp_pixelmap_rotate.c gx_display_driver_16bpp_rotated_block_move.c gx_display_driver_16bpp_rotated_canvas_copy.c gx_display_driver_16bpp_rotated_horizontal_line_draw.c gx_display_driver_16bpp_rotated_horizontal_pattern_line_draw.c gx_display_driver_16bpp_rotated_pixel_write.c gx_display_driver_16bpp_rotated_pixelmap_blend.c gx_display_driver_16bpp_rotated_pixelmap_draw.c gx_display_driver_16bpp_rotated_pixelmap_rotate.c gx_display_driver_16bpp_rotated_simple_line_draw.c gx_display_driver_16bpp_rotated_vertical_line_draw.c gx_display_driver_16bpp_rotated_vertical_pattern_line_draw.c gx_display_driver_16bpp_row_pitch_get.c gx_display_driver_16bpp_simple_line_draw.c gx_display_driver_16bpp_vertical_line_draw.c gx_display_driver_16bpp_vertical_pattern_line_draw.c gx_display_driver_24xrgb_canvas_blend.c gx_display_driver_24xrgb_jpeg_draw.c gx_display_driver_24xrgb_mouse_capture.c gx_display_driver_24xrgb_mouse_restore.c gx_display_driver_24xrgb_native_color_get.c gx_display_driver_24xrgb_pixel_blend.c gx_display_driver_24xrgb_pixelmap_blend.c gx_display_driver_24xrgb_png_draw.c gx_display_driver_24xrgb_rotated_canvas_blend.c gx_display_driver_24xrgb_rotated_jpeg_draw.c gx_display_driver_24xrgb_rotated_pixel_blend.c gx_display_driver_24xrgb_rotated_png_draw.c gx_display_driver_24xrgb_rotated_setup.c gx_display_driver_24xrgb_setup.c gx_display_driver_32argb_native_color_get.c gx_display_driver_32argb_pixel_blend.c gx_display_driver_32argb_pixelmap_blend.c gx_display_driver_32argb_pixelmap_draw.c gx_display_driver_32argb_rotated_pixel_blend.c gx_display_driver_32argb_rotated_setup.c gx_display_driver_32argb_setup.c gx_display_driver_32bpp_block_move.c gx_display_driver_32bpp_canvas_copy.c gx_display_driver_32bpp_glyph_1bit_draw.c gx_display_driver_32bpp_horizontal_line_draw.c gx_display_driver_32bpp_horizontal_pattern_line_draw.c gx_display_driver_32bpp_horizontal_pixelmap_line_draw.c gx_display_driver_32bpp_pixel_write.c gx_display_driver_32bpp_pixelmap_draw.c gx_display_driver_32bpp_pixelmap_rotate.c gx_display_driver_32bpp_rotated_block_move.c gx_display_driver_32bpp_rotated_canvas_copy.c gx_display_driver_32bpp_rotated_glyph_1bit_draw.c gx_display_driver_32bpp_rotated_horizontal_line_draw.c gx_display_driver_32bpp_rotated_horizontal_pattern_line_draw.c gx_display_driver_32bpp_rotated_horizontal_pixelmap_line_draw.c gx_display_driver_32bpp_rotated_pixel_write.c gx_display_driver_32bpp_rotated_pixelmap_blend.c gx_display_driver_32bpp_rotated_pixelmap_draw.c gx_display_driver_32bpp_rotated_pixelmap_rotate.c gx_display_driver_32bpp_rotated_simple_line_draw.c gx_display_driver_32bpp_rotated_vertical_line_draw.c gx_display_driver_32bpp_rotated_vertical_pattern_line_draw.c gx_display_driver_32bpp_row_pitch_get.c gx_display_driver_32bpp_simple_line_draw.c gx_display_driver_32bpp_vertical_line_draw.c gx_display_driver_32bpp_vertical_pattern_line_draw.c gx_display_driver_332rgb_native_color_get.c gx_display_driver_332rgb_pixel_blend.c gx_display_driver_332rgb_pixelmap_draw.c gx_display_driver_332rgb_pixelmap_rotate.c gx_display_driver_332rgb_setup.c gx_display_driver_565rgb_canvas_blend.c gx_display_driver_565rgb_glyph_1bit_draw.c gx_display_driver_565rgb_horizontal_pixelmap_line_draw.c gx_display_driver_565rgb_jpeg_draw.c gx_display_driver_565rgb_native_color_get.c gx_display_driver_565rgb_pixel_blend.c gx_display_driver_565rgb_png_draw.c gx_display_driver_565rgb_rotated_canvas_blend.c gx_display_driver_565rgb_rotated_glyph_1bit_draw.c gx_display_driver_565rgb_rotated_horizontal_pixelmap_line_draw.c gx_display_driver_565rgb_rotated_jpeg_draw.c gx_display_driver_565rgb_rotated_pixel_blend.c gx_display_driver_565rgb_rotated_png_draw.c gx_display_driver_565rgb_rotated_setup.c gx_display_driver_565rgb_setup.c gx_display_driver_1555xrgb_canvas_blend.c gx_display_driver_1555xrgb_jpeg_draw.c gx_display_driver_1555xrgb_native_color_get.c gx_display_driver_1555xrgb_pixel_blend.c gx_display_driver_1555xrgb_pixelmap_rotate.c gx_display_driver_1555xrgb_png_draw.c gx_display_driver_1555xrgb_setup.c gx_display_driver_4444argb_canvas_blend.c gx_display_driver_4444argb_horizontal_pixelmap_line_draw.c gx_display_driver_4444argb_native_color_get.c gx_display_driver_4444argb_pixel_blend.c gx_display_driver_4444argb_pixelmap_draw.c gx_display_driver_4444argb_pixelmap_rotate.c gx_display_driver_4444argb_setup.c gx_display_driver_arc_clipping_get.c gx_display_driver_generic_aliased_arc_draw.c gx_display_driver_generic_aliased_circle_draw.c gx_display_driver_generic_aliased_ellipse_draw.c gx_display_driver_generic_aliased_filled_circle_draw.c gx_display_driver_generic_aliased_fixed_point_line_draw.c gx_display_driver_generic_aliased_line_draw.c gx_display_driver_generic_aliased_wide_arc_draw.c gx_display_driver_generic_aliased_wide_circle_draw.c gx_display_driver_generic_aliased_wide_ellipse_draw.c gx_display_driver_generic_aliased_wide_line_draw.c gx_display_driver_generic_alphamap_draw.c gx_display_driver_generic_arc_draw.c gx_display_driver_generic_arc_fill.c gx_display_driver_generic_circle_draw.c gx_display_driver_generic_circle_fill.c gx_display_driver_generic_drawing_complete.c gx_display_driver_generic_drawing_initiate.c gx_display_driver_generic_ellipse_draw.c gx_display_driver_generic_ellipse_fill.c gx_display_driver_generic_filled_circle_draw.c gx_display_driver_generic_glyph_4bpp_draw.c gx_display_driver_generic_glyph_8bpp_draw.c gx_display_driver_generic_mouse_cursor_define.c gx_display_driver_generic_mouse_draw.c gx_display_driver_generic_mouse_enable.c gx_display_driver_generic_mouse_position_set.c gx_display_driver_generic_pie_fill.c gx_display_driver_generic_polygon_draw.c gx_display_driver_generic_polygon_fill.c gx_display_driver_generic_rotated_alphamap_draw.c gx_display_driver_generic_rotated_arc_fill.c gx_display_driver_generic_rotated_circle_fill.c gx_display_driver_generic_rotated_ellipse_fill.c gx_display_driver_generic_rotated_glyph_4bit_draw.c gx_display_driver_generic_rotated_glyph_8bit_draw.c gx_display_driver_generic_rotated_pie_fill.c gx_display_driver_generic_rotated_polygon_fill.c gx_display_driver_generic_rotated_wide_line_fill.c gx_display_driver_generic_simple_pie_fill.c gx_display_driver_generic_simple_wide_line_draw.c gx_display_driver_generic_wide_arc_draw.c gx_display_driver_generic_wide_circle_draw.c gx_display_driver_generic_wide_ellipse_draw.c gx_display_driver_generic_wide_line_fill.c gx_display_driver_generic_wide_line_points_calculate.c gx_display_driver_horizontal_line_alpha_draw.c gx_display_driver_monochrome_setup.c gx_display_driver_simple_line_alpha_draw.c gx_display_driver_vertical_line_alpha_draw.c gx_display_font_table_set.c gx_display_language_table_get.c gx_display_language_table_set.c gx_display_pixelmap_table_set.c gx_display_string_get.c gx_display_string_table_get.c gx_display_theme_install.c gx_drop_list_background_draw.c gx_drop_list_close.c gx_drop_list_create.c gx_drop_list_draw.c gx_drop_list_event_process.c gx_drop_list_open.c gx_drop_list_pixelmap_set.c gx_drop_list_popup_get.c gx_generic_scroll_wheel_children_position.c gx_generic_scroll_wheel_create.c gx_generic_scroll_wheel_down_wrap.c gx_generic_scroll_wheel_draw.c gx_generic_scroll_wheel_event_process.c gx_generic_scroll_wheel_row_height_set.c gx_generic_scroll_wheel_scroll.c gx_generic_scroll_wheel_total_rows_set.c gx_generic_scroll_wheel_up_wrap.c gx_generic_scroll_wheel_wrap_style_check.c gx_horizontal_list_children_position.c gx_horizontal_list_create.c gx_horizontal_list_event_process.c gx_horizontal_list_left_wrap.c gx_horizontal_list_page_index_set.c gx_horizontal_list_right_wrap.c gx_horizontal_list_scroll.c gx_horizontal_list_scroll_info_get.c gx_horizontal_list_selected_index_get.c gx_horizontal_list_selected_set.c gx_horizontal_list_selected_visible.c gx_horizontal_list_selected_widget_get.c gx_horizontal_list_slide_back_check.c gx_horizontal_list_total_columns_set.c gx_horizontal_scrollbar_create.c gx_icon_background_draw.c gx_icon_button_create.c gx_icon_button_draw.c gx_icon_button_pixelmap_set.c gx_icon_create.c gx_icon_draw.c gx_icon_event_process.c gx_icon_pixelmap_set.c gx_icon_pixelmap_update.c gx_image_reader_colorspace_convert.c gx_image_reader_create.c gx_image_reader_image_decode.c gx_image_reader_jpeg_decode.c gx_image_reader_nearest_palette_color_get.c gx_image_reader_palette_set.c gx_image_reader_pixel_read_callback_set.c gx_image_reader_pixel_write_callback_set.c gx_image_reader_png_decode.c gx_image_reader_rle_encode.c gx_image_reader_start.c gx_line_chart_axis_draw.c gx_line_chart_create.c gx_line_chart_data_draw.c gx_line_chart_draw.c gx_line_chart_update.c gx_line_chart_y_scale_calculate.c gx_menu_create.c gx_menu_draw.c gx_menu_event_process.c gx_menu_insert.c gx_menu_position.c gx_menu_remove.c gx_menu_text_draw.c gx_menu_text_offset_set.c gx_monochrome_driver_disabled_button_line_draw.c gx_multi_line_text_button_create.c gx_multi_line_text_button_draw.c gx_multi_line_text_button_event_process.c gx_multi_line_text_button_line_pointers_set.c gx_multi_line_text_button_text_draw.c gx_multi_line_text_button_text_id_set.c gx_multi_line_text_button_text_set.c gx_multi_line_text_input_backspace.c gx_multi_line_text_input_buffer_clear.c gx_multi_line_text_input_buffer_get.c gx_multi_line_text_input_char_insert.c gx_multi_line_text_input_char_remove.c gx_multi_line_text_input_copy.c gx_multi_line_text_input_create.c gx_multi_line_text_input_cursor_pos_calculate.c gx_multi_line_text_input_cursor_pos_get.c gx_multi_line_text_input_cursor_pos_update.c gx_multi_line_text_input_cursor_visible.c gx_multi_line_text_input_cut.c gx_multi_line_text_input_delete.c gx_multi_line_text_input_down_arrow.c gx_multi_line_text_input_draw.c gx_multi_line_text_input_end.c gx_multi_line_text_input_event_process.c gx_multi_line_text_input_fill_color_set.c gx_multi_line_text_input_highlight_rectangle_get.c gx_multi_line_text_input_home.c gx_multi_line_text_input_keydown_process.c gx_multi_line_text_input_left_arrow.c gx_multi_line_text_input_mark_down.c gx_multi_line_text_input_mark_end.c gx_multi_line_text_input_mark_home.c gx_multi_line_text_input_mark_next.c gx_multi_line_text_input_mark_previous.c gx_multi_line_text_input_mark_up.c gx_multi_line_text_input_paste.c gx_multi_line_text_input_right_arrow.c gx_multi_line_text_input_style_add.c gx_multi_line_text_input_style_remove.c gx_multi_line_text_input_style_set.c gx_multi_line_text_input_text_color_set.c gx_multi_line_text_input_text_rectangle_get.c gx_multi_line_text_input_text_select.c gx_multi_line_text_input_text_set.c gx_multi_line_text_input_up_arrow.c gx_multi_line_text_view_create.c gx_multi_line_text_view_display_info_get.c gx_multi_line_text_view_draw.c gx_multi_line_text_view_event_process.c gx_multi_line_text_view_font_set.c gx_multi_line_text_view_line_cache_update.c gx_multi_line_text_view_line_space_set.c gx_multi_line_text_view_scroll.c gx_multi_line_text_view_scroll_info_get.c gx_multi_line_text_view_string_total_rows_compute.c gx_multi_line_text_view_text_color_set.c gx_multi_line_text_view_text_draw.c gx_multi_line_text_view_text_id_set.c gx_multi_line_text_view_text_set.c gx_multi_line_text_view_visible_rows_compute.c gx_multi_line_text_view_whitespace_set.c gx_numeric_pixelmap_prompt_create.c gx_numeric_pixelmap_prompt_format.c gx_numeric_pixelmap_prompt_format_function_set.c gx_numeric_pixelmap_prompt_value_set.c gx_numeric_prompt_create.c gx_numeric_prompt_format.c gx_numeric_prompt_format_function_set.c gx_numeric_prompt_value_set.c gx_numeric_scroll_wheel_create.c gx_numeric_scroll_wheel_range_set.c gx_numeric_scroll_wheel_text_get.c gx_pixelmap_button_create.c gx_pixelmap_button_draw.c gx_pixelmap_button_event_process.c gx_pixelmap_button_pixelmap_set.c gx_pixelmap_button_transparent_detect.c gx_pixelmap_prompt_background_draw.c gx_pixelmap_prompt_create.c gx_pixelmap_prompt_draw.c gx_pixelmap_prompt_pixelmap_set.c gx_pixelmap_slider_create.c gx_pixelmap_slider_draw.c gx_pixelmap_slider_event_process.c gx_pixelmap_slider_pixelmap_set.c gx_pixelmap_slider_pixelmap_update.c gx_popup_list_event_process.c gx_progress_bar_background_draw.c gx_progress_bar_create.c gx_progress_bar_draw.c gx_progress_bar_event_process.c gx_progress_bar_font_set.c gx_progress_bar_info_set.c gx_progress_bar_pixelmap_set.c gx_progress_bar_range_set.c gx_progress_bar_text_color_set.c gx_progress_bar_text_draw.c gx_progress_bar_value_set.c gx_prompt_create.c gx_prompt_draw.c gx_prompt_event_process.c gx_prompt_font_set.c gx_prompt_text_color_set.c gx_prompt_text_draw.c gx_prompt_text_get.c gx_prompt_text_id_set.c gx_prompt_text_set.c gx_radial_progress_bar_anchor_set.c gx_radial_progress_bar_background_draw.c gx_radial_progress_bar_create.c gx_radial_progress_bar_draw.c gx_radial_progress_bar_event_process.c gx_radial_progress_bar_font_set.c gx_radial_progress_bar_info_set.c gx_radial_progress_bar_resize.c gx_radial_progress_bar_size_update.c gx_radial_progress_bar_text_color_set.c gx_radial_progress_bar_text_draw.c gx_radial_progress_bar_value_calculate.c gx_radial_progress_bar_value_set.c gx_radial_slider_anchor_angle_calculate.c gx_radial_slider_anchor_angles_set.c gx_radial_slider_angle_calculate.c gx_radial_slider_angle_set.c gx_radial_slider_animation_set.c gx_radial_slider_animation_start.c gx_radial_slider_animation_update.c gx_radial_slider_create.c gx_radial_slider_draw.c gx_radial_slider_event_process.c gx_radial_slider_info_get.c gx_radial_slider_info_set.c gx_radial_slider_needle_rectangle_calculate.c gx_radial_slider_pixelmap_set.c gx_radio_button_create.c gx_radio_button_draw.c gx_radio_button_pixelmap_set.c gx_rich_text_view_context_peek.c gx_rich_text_view_context_pop.c gx_rich_text_view_context_push.c gx_rich_text_view_context_reset.c gx_rich_text_view_context_restore.c gx_rich_text_view_context_save.c gx_rich_text_view_create.c gx_rich_text_view_draw.c gx_rich_text_view_fonts_set.c gx_rich_text_view_line_info_get.c gx_rich_text_view_scroll_info_get.c gx_rich_text_view_tag_enter.c gx_rich_text_view_text_draw.c gx_rich_text_view_text_total_height_calculate.c gx_screen_stack_create.c gx_screen_stack_pop.c gx_screen_stack_push.c gx_screen_stack_reset.c gx_scroll_thumb_create.c gx_scroll_thumb_draw.c gx_scroll_thumb_event_process.c gx_scroll_thumb_shift_limit.c gx_scroll_wheel_create.c gx_scroll_wheel_event_process.c gx_scroll_wheel_gradient_alpha_set.c gx_scroll_wheel_gradient_create.c gx_scroll_wheel_row_height_set.c gx_scroll_wheel_scroll.c gx_scroll_wheel_selected_background_set.c gx_scroll_wheel_selected_get.c gx_scroll_wheel_selected_row_calculate.c gx_scroll_wheel_selected_set.c gx_scroll_wheel_speed_set.c gx_scroll_wheel_total_rows_set.c gx_scroll_wheel_wrap_style_check.c gx_scrollbar_draw.c gx_scrollbar_event_process.c gx_scrollbar_limit_check.c gx_scrollbar_reset.c gx_scrollbar_size_update.c gx_scrollbar_thumb_position_calculate.c gx_scrollbar_value_calculate.c gx_scrollbar_value_set.c gx_single_line_text_input_backspace.c gx_single_line_text_input_buffer_clear.c gx_single_line_text_input_buffer_get.c gx_single_line_text_input_character_delete.c gx_single_line_text_input_character_insert.c gx_single_line_text_input_copy.c gx_single_line_text_input_create.c gx_single_line_text_input_cut.c gx_single_line_text_input_draw.c gx_single_line_text_input_draw_position_get.c gx_single_line_text_input_end.c gx_single_line_text_input_event_process.c gx_single_line_text_input_fill_color_set.c gx_single_line_text_input_home.c gx_single_line_text_input_keydown_process.c gx_single_line_text_input_left_arrow.c gx_single_line_text_input_mark_end.c gx_single_line_text_input_mark_home.c gx_single_line_text_input_mark_next.c gx_single_line_text_input_mark_previous.c gx_single_line_text_input_paste.c gx_single_line_text_input_position_get.c gx_single_line_text_input_position_update.c gx_single_line_text_input_right_arrow.c gx_single_line_text_input_style_add.c gx_single_line_text_input_style_remove.c gx_single_line_text_input_style_set.c gx_single_line_text_input_text_color_set.c gx_single_line_text_input_text_rectangle_get.c gx_single_line_text_input_text_select.c gx_single_line_text_input_text_set.c gx_slider_create.c gx_slider_draw.c gx_slider_event_process.c gx_slider_info_set.c gx_slider_needle_draw.c gx_slider_needle_position_get.c gx_slider_tickmarks_draw.c gx_slider_travel_get.c gx_slider_value_calculate.c gx_slider_value_set.c gx_sprite_create.c gx_sprite_current_frame_set.c gx_sprite_draw.c gx_sprite_event_process.c gx_sprite_frame_list_set.c gx_sprite_start.c gx_sprite_stop.c gx_sprite_update.c gx_string_scroll_wheel_create.c gx_string_scroll_wheel_event_process.c gx_string_scroll_wheel_string_id_list_set.c gx_string_scroll_wheel_string_list_set.c gx_string_scroll_wheel_text_get.c gx_system_active_language_set.c gx_system_all_canvas_dirty.c gx_system_all_views_free.c gx_system_animation_free.c gx_system_animation_get.c gx_system_bidi_text_disable.c gx_system_bidi_text_enable.c gx_system_canvas_refresh.c gx_system_clipboard_get.c gx_system_clipboard_put.c gx_system_dirty_list_remove.c gx_system_dirty_list_trim.c gx_system_dirty_mark.c gx_system_dirty_partial_add.c gx_system_draw_context_get.c gx_system_error_process.c gx_system_event_dispatch.c gx_system_event_fold.c gx_system_event_remove.c gx_system_event_send.c gx_system_focus_claim.c gx_system_font_4bpp.c gx_system_font_8bpp.c gx_system_font_mono.c gx_system_free_view_get.c gx_system_initialize.c gx_system_input_capture.c gx_system_input_release.c gx_system_language_table_get.c gx_system_language_table_set.c gx_system_lock.c gx_system_memory_allocator_set.c gx_system_pen_configure.c gx_system_pen_flick_test.c gx_system_pen_speed_init.c gx_system_pen_speed_update.c gx_system_private_string.c gx_system_root_view_add.c gx_system_rtos_bind.c gx_system_screen_stack_create.c gx_system_screen_stack_get.c gx_system_screen_stack_pop.c gx_system_screen_stack_push.c gx_system_screen_stack_reset.c gx_system_scroll_appearance_get.c gx_system_scroll_appearance_set.c gx_system_start.c gx_system_string_get.c gx_system_string_table_get.c gx_system_string_width_get.c gx_system_text_render_style_set.c gx_system_thread_entry.c gx_system_timer_expiration.c gx_system_timer_start.c gx_system_timer_stop.c gx_system_timer_update.c gx_system_top_root_find.c gx_system_top_widget_find.c gx_system_unlock.c gx_system_version_string_get.c gx_system_view_add.c gx_system_view_fold.c gx_system_view_split.c gx_system_views_free.c gx_system_views_update.c gx_system_widget_find.c gx_text_button_create.c gx_text_button_draw.c gx_text_button_event_process.c gx_text_button_font_set.c gx_text_button_text_color_set.c gx_text_button_text_draw.c gx_text_button_text_get.c gx_text_button_text_id_set.c gx_text_button_text_set.c gx_text_input_cursor_blink_interval_set.c gx_text_input_cursor_dirty_rectangle_get.c gx_text_input_cursor_draw.c gx_text_input_cursor_height_set.c gx_text_input_cursor_width_set.c gx_text_scroll_wheel_callback_set.c gx_text_scroll_wheel_create.c gx_text_scroll_wheel_draw.c gx_text_scroll_wheel_dynamic_bidi_text_delete.c gx_text_scroll_wheel_event_process.c gx_text_scroll_wheel_font_set.c gx_text_scroll_wheel_text_color_set.c gx_touch_driver_generic_resistive.c gx_tree_view_create.c gx_tree_view_draw.c gx_tree_view_event_process.c gx_tree_view_indentation_set.c gx_tree_view_position.c gx_tree_view_root_line_color_set.c gx_tree_view_root_pixelmap_set.c gx_tree_view_scroll.c gx_tree_view_scroll_info_get.c gx_tree_view_selected_get.c gx_tree_view_selected_set.c gx_utility_1bpp_pixelmap_resize.c gx_utility_1bpp_pixelmap_rotate.c gx_utility_4bpp_pixelmap_resize.c gx_utility_4bpp_pixelmap_rotate.c gx_utility_8bpp_pixelmap_resize.c gx_utility_8bpp_pixelmap_rotate.c gx_utility_16bpp_pixelmap_resize.c gx_utility_32argb_pixelmap_resize.c gx_utility_32argb_pixelmap_rotate.c gx_utility_332rgb_pixelmap_rotate.c gx_utility_565rgb_pixelmap_rotate.c gx_utility_1555xrgb_pixelmap_resize.c gx_utility_1555xrgb_pixelmap_rotate.c gx_utility_4444argb_pixelmap_resize.c gx_utility_4444argb_pixelmap_rotate.c gx_utility_alphamap_create.c gx_utility_bidi_arabic_shaping.c gx_utility_bidi_bracket_pair_get.c gx_utility_bidi_character_type_get.c gx_utility_bidi_mirroring_get.c gx_utility_bidi_paragraph_reorder.c gx_utility_bidi_resolved_text_info_delete.c gx_utility_canvas_to_bmp.c gx_utility_circle_point_get.c gx_utility_easing_function_calculate.c gx_utility_gradient_create.c gx_utility_gradient_delete.c gx_utility_ltoa.c gx_utility_math_acos.c gx_utility_math_asin.c gx_utility_math_cos.c gx_utility_math_sin.c gx_utility_math_sqrt.c gx_utility_pixelmap_resize.c gx_utility_pixelmap_rotate.c gx_utility_pixelmap_simple_rotate.c gx_utility_rectangle_center.c gx_utility_rectangle_center_find.c gx_utility_rectangle_combine.c gx_utility_rectangle_compare.c gx_utility_rectangle_define.c gx_utility_rectangle_inside_detect.c gx_utility_rectangle_overlap_detect.c gx_utility_rectangle_point_detect.c gx_utility_rectangle_resize.c gx_utility_rectangle_shift.c gx_utility_string_compare.c gx_utility_string_length_check.c gx_utility_string_to_alphamap.c gx_utility_thai_glyph_shaping.c gx_utility_unicode_to_utf8.c gx_utility_utf8_string_backward_character_length_get.c gx_utility_utf8_string_character_get.c gx_vertical_list_children_position.c gx_vertical_list_create.c gx_vertical_list_down_wrap.c gx_vertical_list_event_process.c gx_vertical_list_page_index_set.c gx_vertical_list_scroll.c gx_vertical_list_scroll_info_get.c gx_vertical_list_selected_index_get.c gx_vertical_list_selected_set.c gx_vertical_list_selected_visible.c gx_vertical_list_selected_widget_get.c gx_vertical_list_slide_back_check.c gx_vertical_list_total_rows_set.c gx_vertical_list_up_wrap.c gx_vertical_scrollbar_create.c gx_widget_allocate.c gx_widget_attach.c gx_widget_back_attach.c gx_widget_back_link.c gx_widget_back_move.c gx_widget_background_draw.c gx_widget_block_move.c gx_widget_border_draw.c gx_widget_border_style_set.c gx_widget_border_width_get.c gx_widget_canvas_get.c gx_widget_child_clipping_update.c gx_widget_child_detect.c gx_widget_child_focus_assign.c gx_widget_children_draw.c gx_widget_children_event_process.c gx_widget_client_get.c gx_widget_client_index_get.c gx_widget_clipping_update.c gx_widget_color_get.c gx_widget_context_fill_set.c gx_widget_create.c gx_widget_created_test.c gx_widget_delete.c gx_widget_detach.c gx_widget_draw.c gx_widget_draw_set.c gx_widget_event_generate.c gx_widget_event_process.c gx_widget_event_process_set.c gx_widget_event_to_parent.c gx_widget_fill_color_set.c gx_widget_find.c gx_widget_first_child_get.c gx_widget_first_client_child_get.c gx_widget_focus_next.c gx_widget_focus_previous.c gx_widget_font_get.c gx_widget_free.c gx_widget_front_move.c gx_widget_height_get.c gx_widget_hide.c gx_widget_last_child_get.c gx_widget_last_client_child_get.c gx_widget_link.c gx_widget_nav_order_initialize.c gx_widget_next_client_child_get.c gx_widget_next_sibling_get.c gx_widget_parent_get.c gx_widget_pixelmap_get.c gx_widget_previous_sibling_get.c gx_widget_resize.c gx_widget_scroll_shift.c gx_widget_shift.c gx_widget_show.c gx_widget_status_add.c gx_widget_status_get.c gx_widget_status_remove.c gx_widget_status_test.c gx_widget_string_get.c gx_widget_style_add.c gx_widget_style_get.c gx_widget_style_remove.c gx_widget_style_set.c gx_widget_text_blend.c gx_widget_text_draw.c gx_widget_text_id_draw.c gx_widget_top_visible_child_find.c gx_widget_transparent_pixelmap_detect.c gx_widget_type_find.c gx_widget_unlink.c gx_widget_width_get.c gx_window_background_draw.c gx_window_border_draw.c gx_window_client_height_get.c gx_window_client_scroll.c gx_window_client_width_get.c gx_window_close.c gx_window_create.c gx_window_draw.c gx_window_event_process.c gx_window_execute.c gx_window_root_create.c gx_window_root_delete.c gx_window_root_event_process.c gx_window_root_find.c gx_window_scroll.c gx_window_scroll_info_get.c gx_window_scrollbar_find.c gx_window_view_update_detect.c gx_window_wallpaper_get.c gx_window_wallpaper_set.c gxe_accordion_menu_create.c gxe_accordion_menu_event_process.c gxe_accordion_menu_position.c gxe_animation_canvas_define.c gxe_animation_create.c gxe_animation_delete.c gxe_animation_drag_disable.c gxe_animation_drag_enable.c gxe_animation_landing_speed_set.c gxe_animation_start.c gxe_animation_stop.c gxe_binres_language_count_get.c gxe_binres_language_info_load.c gxe_binres_language_table_load.c gxe_binres_theme_load.c gxe_brush_default.c gxe_brush_define.c gxe_button_create.c gxe_button_deselect.c gxe_button_event_process.c gxe_button_select.c gxe_canvas_alpha_set.c gxe_canvas_arc_draw.c gxe_canvas_block_move.c gxe_canvas_circle_draw.c gxe_canvas_create.c gxe_canvas_delete.c gxe_canvas_drawing_complete.c gxe_canvas_drawing_initiate.c gxe_canvas_ellipse_draw.c gxe_canvas_hardware_layer_bind.c gxe_canvas_hide.c gxe_canvas_line_draw.c gxe_canvas_memory_define.c gxe_canvas_mouse_define.c gxe_canvas_mouse_hide.c gxe_canvas_mouse_show.c gxe_canvas_offset_set.c gxe_canvas_pie_draw.c gxe_canvas_pixel_draw.c gxe_canvas_pixelmap_blend.c gxe_canvas_pixelmap_draw.c gxe_canvas_pixelmap_get.c gxe_canvas_pixelmap_rotate.c gxe_canvas_pixelmap_tile.c gxe_canvas_polygon_draw.c gxe_canvas_rectangle_draw.c gxe_canvas_rotated_text_draw.c gxe_canvas_shift.c gxe_canvas_show.c gxe_canvas_text_draw.c gxe_checkbox_create.c gxe_checkbox_event_process.c gxe_checkbox_pixelmap_set.c gxe_checkbox_select.c gxe_circular_gauge_angle_get.c gxe_circular_gauge_angle_set.c gxe_circular_gauge_animation_set.c gxe_circular_gauge_create.c gxe_circular_gauge_event_process.c gxe_context_brush_default.c gxe_context_brush_define.c gxe_context_brush_get.c gxe_context_brush_pattern_set.c gxe_context_brush_set.c gxe_context_brush_style_set.c gxe_context_brush_width_set.c gxe_context_color_get.c gxe_context_fill_color_set.c gxe_context_font_get.c gxe_context_font_set.c gxe_context_line_color_set.c gxe_context_pixelmap_get.c gxe_context_pixelmap_set.c gxe_context_raw_brush_define.c gxe_context_raw_fill_color_set.c gxe_context_raw_line_color_set.c gxe_context_string_get.c gxe_display_active_language_set.c gxe_display_color_set.c gxe_display_color_table_set.c gxe_display_create.c gxe_display_delete.c gxe_display_font_table_set.c gxe_display_language_table_get.c gxe_display_language_table_set.c gxe_display_pixelmap_table_set.c gxe_display_string_get.c gxe_display_string_table_get.c gxe_display_theme_install.c gxe_drop_list_close.c gxe_drop_list_create.c gxe_drop_list_event_process.c gxe_drop_list_open.c gxe_drop_list_pixelmap_set.c gxe_drop_list_popup_get.c gxe_generic_scroll_wheel_children_position.c gxe_generic_scroll_wheel_create.c gxe_generic_scroll_wheel_event_process.c gxe_generic_scroll_wheel_row_height_set.c gxe_generic_scroll_wheel_total_rows_set.c gxe_horizontal_list_children_position.c gxe_horizontal_list_create.c gxe_horizontal_list_event_process.c gxe_horizontal_list_page_index_set.c gxe_horizontal_list_selected_index_get.c gxe_horizontal_list_selected_set.c gxe_horizontal_list_selected_widget_get.c gxe_horizontal_list_total_columns_set.c gxe_horizontal_scrollbar_create.c gxe_icon_button_create.c gxe_icon_button_pixelmap_set.c gxe_icon_create.c gxe_icon_event_process.c gxe_icon_pixelmap_set.c gxe_image_reader_create.c gxe_image_reader_palette_set.c gxe_image_reader_start.c gxe_line_chart_create.c gxe_line_chart_update.c gxe_line_chart_y_scale_calculate.c gxe_menu_create.c gxe_menu_event_process.c gxe_menu_insert.c gxe_menu_remove.c gxe_menu_text_offset_set.c gxe_multi_line_text_button_create.c gxe_multi_line_text_button_event_process.c gxe_multi_line_text_button_text_id_set.c gxe_multi_line_text_button_text_set.c gxe_multi_line_text_input_backspace.c gxe_multi_line_text_input_buffer_clear.c gxe_multi_line_text_input_buffer_get.c gxe_multi_line_text_input_char_insert.c gxe_multi_line_text_input_create.c gxe_multi_line_text_input_cursor_pos_get.c gxe_multi_line_text_input_delete.c gxe_multi_line_text_input_down_arrow.c gxe_multi_line_text_input_end.c gxe_multi_line_text_input_event_process.c gxe_multi_line_text_input_fill_color_set.c gxe_multi_line_text_input_home.c gxe_multi_line_text_input_left_arrow.c gxe_multi_line_text_input_right_arrow.c gxe_multi_line_text_input_style_add.c gxe_multi_line_text_input_style_remove.c gxe_multi_line_text_input_style_set.c gxe_multi_line_text_input_text_color_set.c gxe_multi_line_text_input_text_select.c gxe_multi_line_text_input_text_set.c gxe_multi_line_text_input_up_arrow.c gxe_multi_line_text_view_create.c gxe_multi_line_text_view_event_process.c gxe_multi_line_text_view_font_set.c gxe_multi_line_text_view_line_space_set.c gxe_multi_line_text_view_scroll_info_get.c gxe_multi_line_text_view_text_color_set.c gxe_multi_line_text_view_text_id_set.c gxe_multi_line_text_view_text_set.c gxe_multi_line_text_view_whitespace_set.c gxe_numeric_pixelmap_prompt_create.c gxe_numeric_pixelmap_prompt_format_function_set.c gxe_numeric_pixelmap_prompt_value_set.c gxe_numeric_prompt_create.c gxe_numeric_prompt_format_function_set.c gxe_numeric_prompt_value_set.c gxe_numeric_scroll_wheel_create.c gxe_numeric_scroll_wheel_range_set.c gxe_pixelmap_button_create.c gxe_pixelmap_button_event_process.c gxe_pixelmap_button_pixelmap_set.c gxe_pixelmap_prompt_create.c gxe_pixelmap_prompt_pixelmap_set.c gxe_pixelmap_slider_create.c gxe_pixelmap_slider_event_process.c gxe_pixelmap_slider_pixelmap_set.c gxe_progress_bar_create.c gxe_progress_bar_event_process.c gxe_progress_bar_font_set.c gxe_progress_bar_info_set.c gxe_progress_bar_pixelmap_set.c gxe_progress_bar_range_set.c gxe_progress_bar_text_color_set.c gxe_progress_bar_value_set.c gxe_prompt_create.c gxe_prompt_event_process.c gxe_prompt_font_set.c gxe_prompt_text_color_set.c gxe_prompt_text_get.c gxe_prompt_text_id_set.c gxe_prompt_text_set.c gxe_radial_progress_bar_anchor_set.c gxe_radial_progress_bar_create.c gxe_radial_progress_bar_event_process.c gxe_radial_progress_bar_font_set.c gxe_radial_progress_bar_info_set.c gxe_radial_progress_bar_text_color_set.c gxe_radial_progress_bar_value_set.c gxe_radial_slider_anchor_angles_set.c gxe_radial_slider_angle_set.c gxe_radial_slider_animation_set.c gxe_radial_slider_animation_start.c gxe_radial_slider_create.c gxe_radial_slider_event_process.c gxe_radial_slider_info_get.c gxe_radial_slider_info_set.c gxe_radial_slider_pixelmap_set.c gxe_radio_button_create.c gxe_radio_button_pixelmap_set.c gxe_rich_text_view_create.c gxe_rich_text_view_fonts_set.c gxe_screen_stack_create.c gxe_screen_stack_pop.c gxe_screen_stack_push.c gxe_screen_stack_reset.c gxe_scroll_thumb_create.c gxe_scroll_thumb_event_process.c gxe_scroll_wheel_create.c gxe_scroll_wheel_event_process.c gxe_scroll_wheel_gradient_alpha_set.c gxe_scroll_wheel_row_height_set.c gxe_scroll_wheel_selected_background_set.c gxe_scroll_wheel_selected_get.c gxe_scroll_wheel_selected_set.c gxe_scroll_wheel_speed_set.c gxe_scroll_wheel_total_rows_set.c gxe_scrollbar_event_process.c gxe_scrollbar_limit_check.c gxe_scrollbar_reset.c gxe_scrollbar_value_set.c gxe_single_line_text_input_backspace.c gxe_single_line_text_input_buffer_clear.c gxe_single_line_text_input_buffer_get.c gxe_single_line_text_input_character_delete.c gxe_single_line_text_input_character_insert.c gxe_single_line_text_input_create.c gxe_single_line_text_input_draw_position_get.c gxe_single_line_text_input_end.c gxe_single_line_text_input_event_process.c gxe_single_line_text_input_fill_color_set.c gxe_single_line_text_input_home.c gxe_single_line_text_input_left_arrow.c gxe_single_line_text_input_position_get.c gxe_single_line_text_input_right_arrow.c gxe_single_line_text_input_style_add.c gxe_single_line_text_input_style_remove.c gxe_single_line_text_input_style_set.c gxe_single_line_text_input_text_color_set.c gxe_single_line_text_input_text_select.c gxe_single_line_text_input_text_set.c gxe_slider_create.c gxe_slider_event_process.c gxe_slider_info_set.c gxe_slider_needle_position_get.c gxe_slider_travel_get.c gxe_slider_value_calculate.c gxe_slider_value_set.c gxe_sprite_create.c gxe_sprite_current_frame_set.c gxe_sprite_frame_list_set.c gxe_sprite_start.c gxe_sprite_stop.c gxe_string_scroll_wheel_create.c gxe_string_scroll_wheel_event_process.c gxe_string_scroll_wheel_string_id_list_set.c gxe_string_scroll_wheel_string_list_set.c gxe_system_active_language_set.c gxe_system_animation_free.c gxe_system_animation_get.c gxe_system_canvas_refresh.c gxe_system_dirty_mark.c gxe_system_dirty_partial_add.c gxe_system_draw_context_get.c gxe_system_event_fold.c gxe_system_event_send.c gxe_system_focus_claim.c gxe_system_initialize.c gxe_system_language_table_get.c gxe_system_language_table_set.c gxe_system_memory_allocator_set.c gxe_system_pen_configure.c gxe_system_screen_stack_create.c gxe_system_screen_stack_get.c gxe_system_screen_stack_pop.c gxe_system_screen_stack_push.c gxe_system_scroll_appearance_get.c gxe_system_scroll_appearance_set.c gxe_system_start.c gxe_system_string_get.c gxe_system_string_table_get.c gxe_system_string_width_get.c gxe_system_timer_start.c gxe_system_timer_stop.c gxe_system_version_string_get.c gxe_system_widget_find.c gxe_text_button_create.c gxe_text_button_event_process.c gxe_text_button_font_set.c gxe_text_button_text_color_set.c gxe_text_button_text_get.c gxe_text_button_text_id_set.c gxe_text_button_text_set.c gxe_text_input_cursor_blink_interval_set.c gxe_text_input_cursor_height_set.c gxe_text_input_cursor_width_set.c gxe_text_scroll_wheel_callback_set.c gxe_text_scroll_wheel_create.c gxe_text_scroll_wheel_event_process.c gxe_text_scroll_wheel_font_set.c gxe_text_scroll_wheel_text_color_set.c gxe_tree_view_create.c gxe_tree_view_event_process.c gxe_tree_view_indentation_set.c gxe_tree_view_position.c gxe_tree_view_root_line_color_set.c gxe_tree_view_root_pixelmap_set.c gxe_tree_view_selected_get.c gxe_tree_view_selected_set.c gxe_utility_bidi_paragraph_reorder.c gxe_utility_bidi_resolved_text_info_delete.c gxe_utility_canvas_to_bmp.c gxe_utility_circle_point_get.c gxe_utility_gradient_create.c gxe_utility_gradient_delete.c gxe_utility_ltoa.c gxe_utility_pixelmap_resize.c gxe_utility_pixelmap_rotate.c gxe_utility_pixelmap_simple_rotate.c gxe_utility_rectangle_center.c gxe_utility_rectangle_center_find.c gxe_utility_rectangle_combine.c gxe_utility_rectangle_compare.c gxe_utility_rectangle_define.c gxe_utility_rectangle_overlap_detect.c gxe_utility_rectangle_point_detect.c gxe_utility_rectangle_resize.c gxe_utility_rectangle_shift.c gxe_utility_string_to_alphamap.c gxe_vertical_list_children_position.c gxe_vertical_list_create.c gxe_vertical_list_event_process.c gxe_vertical_list_page_index_set.c gxe_vertical_list_selected_index_get.c gxe_vertical_list_selected_set.c gxe_vertical_list_selected_widget_get.c gxe_vertical_list_total_rows_set.c gxe_vertical_scrollbar_create.c gxe_widget_allocate.c gxe_widget_attach.c gxe_widget_back_attach.c gxe_widget_back_move.c gxe_widget_block_move.c gxe_widget_border_style_set.c gxe_widget_border_width_get.c gxe_widget_canvas_get.c gxe_widget_child_detect.c gxe_widget_client_get.c gxe_widget_color_get.c gxe_widget_create.c gxe_widget_created_test.c gxe_widget_delete.c gxe_widget_detach.c gxe_widget_draw_set.c gxe_widget_event_generate.c gxe_widget_event_process.c gxe_widget_event_process_set.c gxe_widget_event_to_parent.c gxe_widget_fill_color_set.c gxe_widget_find.c gxe_widget_first_child_get.c gxe_widget_focus_next.c gxe_widget_focus_previous.c gxe_widget_font_get.c gxe_widget_free.c gxe_widget_front_move.c gxe_widget_height_get.c gxe_widget_hide.c gxe_widget_last_child_get.c gxe_widget_next_sibling_get.c gxe_widget_parent_get.c gxe_widget_pixelmap_get.c gxe_widget_previous_sibling_get.c gxe_widget_resize.c gxe_widget_shift.c gxe_widget_show.c gxe_widget_status_add.c gxe_widget_status_get.c gxe_widget_status_remove.c gxe_widget_status_test.c gxe_widget_string_get.c gxe_widget_style_add.c gxe_widget_style_get.c gxe_widget_style_remove.c gxe_widget_style_set.c gxe_widget_text_blend.c gxe_widget_top_visible_child_find.c gxe_widget_type_find.c gxe_widget_width_get.c gxe_window_client_height_get.c gxe_window_client_scroll.c gxe_window_client_width_get.c gxe_window_close.c gxe_window_create.c gxe_window_event_process.c gxe_window_execute.c gxe_window_root_create.c gxe_window_root_delete.c gxe_window_root_event_process.c gxe_window_root_find.c gxe_window_scroll_info_get.c gxe_window_scrollbar_find.c gxe_window_wallpaper_get.c gxe_window_wallpaper_set.c
  group GUIX/Ports
    ../../GUIX/ports/cortex_m7/ac6/src/: gx_display_driver_stm32h7_565rgb.c
    ../../GUIX/ports/cortex_m7/ac6/inc/: gx_display_driver_stm32h7_565rgb.h
  group GUIX/Demo
    ../../User/guix/: App_SysFunction.c MainTask.c MainTask.h guiapp_resources.c guiapp_resources.h guiapp_specifications.c guiapp_specifications.h
  group Fonts
    ../../User/fonts/: asc12.c asc16.c asc24.c asc32.c hz12.c hz16.c hz24.c hz32.c ra8875_asc_width.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt
